# Keil uVision project Template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__FPU_PRESENT = 1,EMPL,MPU9250,EMPL_TARGET_STM32F4
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\HARDWARE;..\MENU;..\FUNCTION;..\DSP_LIB;..\DSP_LIB\Include;..\FATFS\exfuns;..\FATFS\src;..\MOVE;..\DMP\eMPL-hal;..\DMP\mllite;..\DMP\mpl;..\DMP\driver\eMPL;..\DMP\driver\include;..\DMP\driver\stm32L;..\UCOSIII\uC-LIB;..\UCOSIII\uC-CPU;..\UCOSIII\uCOS-III;..\UCOSIII\uCOS-BSP;..\UCOSIII\uCOS-CONFIG;..\UCOSIII\uCOS-III\Source;..\UCOSIII\uC-CPU\ARM-Cortex-M4\RealView;..\UCOSIII\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\UCOSIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\GPS;..\ROUTE
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group MOVE
    ../MOVE/: pid.c
  group HARDWARE
    ../HARDWARE/: led.c exti.c key.c usart.c pwm.c lcd.c font.c touch.c ccd.c qei.c malloc.c sdio_sdcard.c sram.c timer.c can_database.c can.c mpu9250.c mpuiic.c motor.c
    ./: omvi2c.c handle.c handle.h
  group MENU
    ../MENU/: M_List.c M_Func.c M_Sys.c
  group FUNCTION
    ../FUNCTION/: mymath.c
  group FATFS
    ../FATFS/exfuns/: exfuns.c
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/src/option/: cc936.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group DSP_LIB
    ../DSP_LIB/: arm_cortexM4lf_math.lib
  group README
    ../: readme.txt
  group DMP
    ../DMP/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../DMP/driver/stm32L/: log_stm32.c
    ../DMP/eMPL-hal/: eMPL_outputs.c
    ../DMP/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
    ../DMP/mpl/: libmpllib.lib
  group UCOSIII_BSP
    ../UCOSIII/uCOS-BSP/: bsp.c
  group UCOSIII_CPU
    ../UCOSIII/uC-CPU/: cpu_core.c
    ../UCOSIII/uC-CPU/ARM-Cortex-M4/RealView/: cpu_a.asm cpu_c.c
  group UCOSIII_LIB
    ../UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../UCOSIII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group UCOSIII_CORE
    ../UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_PORT
    ../UCOSIII/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu_c.c os_cpu_a.asm
  group UCOSIII_CONFIG
    ../UCOSIII/uCOS-CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group GPS
    ../GPS/: gyro.c command.c gps.c encoder.c
  group ROUTE
    ../ROUTE/: machine.c pointpath.c route.c PointRoute.c
